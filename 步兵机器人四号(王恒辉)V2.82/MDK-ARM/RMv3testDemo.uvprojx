# Keil uVision project RMv3testDemo.uvprojx, settings and files
target RMv3testDemo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RMv3testDemo +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,ROBOT1
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Hardware\include;..\User\include;..\User\iwdog
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group User
    ../User/source/: main.c Task_tim.c stm32f4xx_it.c
    ../User/include/: config.h
  group Hardware
    ../User/source/: Motor_Chassis.c Motor_Pitch.c Motor_Shoot.c Driver_DBUS.c Control_Vision.c Driver_usart.c referee_sys.c Driver_can.c Algorithm_pid.c Driver_led.c Driver_beep.c Driver_imu.c Driver_usb.c system_clock.c Algorithm_fuzzy.c Driver_oled.c
  group Configeration
    ../Hardware/source/: INIT_TIM.c INIT_CAN.c INIT_SPI.c INIT_DMA.c INIT_GPIO.c INIT_USART.c usbd_cdc_if.c usbd_conf.c usbd_desc.c stm32f4xx_hal_msp.c usb_device.c
    ../User/iwdog/: INIT_IWDOG.c
  group Libraries
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_ll_usb.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_iwdg.c
  group Middlewares/Drivers
    ../Drivers/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Drivers/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./: startup_stm32f427xx.s
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group ReadMe
    ../: readme.txt
software components: CMSIS:CORE 5.0.1
